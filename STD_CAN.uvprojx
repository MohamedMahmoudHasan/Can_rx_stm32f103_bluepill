# Keil uVision project STD_CAN.uvprojx, settings and files
target stm32f103xx (6130001::V6.13.1::.\ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STD_CAN +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Files;..\Can_Rx
  memory RVCT4: ROM 0x8000000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group inc
    ./Files/: BIT_MATH.h CAN.h GPIO_config2.h GPIO_interface2.h GPIO_private2.h NVIC_Config.h NVIC_Interface.h NVIC_Private.h RCC_config.h RCC_interface.h RCC_private.h STD_TYPES.h STK_Config.h STK_Interface.h STK_Private.h stm32f10x_conf.h USART_config.h USART_interface.h USART_private.h
    ./: Can_config.h
  group src
    ./Files/: CAN .c GPIO_program2.c main.c STK_Program.c NVIC_Program.c RCC_program.c USART_program.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
